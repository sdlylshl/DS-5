# Keil uVision project 2440Test.uvproj, settings and files
target Test (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: Test +hex
  AfterMake: d:\Keil\ARM\BIN40\fromelf.exe --bin -o ./Obj/Test.bin ./Obj/Test.axf
  c flags: Optim=4
  c include: ..\common\inc;..\inc
  asm include: ..\common\src
  memory RVCT1: ROM 0x0 size 0x800000
  memory RVCT6: RAM 0x30000000 size 0x800000
  memory RVCT9: RAM 0x40000000 size 0x1000
  scatter file: ..\common\RuninRAM.sct
  group startup
    ../ASM/: 2440init.s 2440slib.s
  group Source Files
    ../src/: 39VF160.C 2440lib.c CH7026_IIC.c comload.c eeprom.c intel_flash.c lcd.c memtest.c mmu.c nand.c nand_lowlevel.c profile.c relocate_nkbin.c u2440mon.c
  group usb
    ../usb/: usb.h usbin.c usbin.h usblib.c usblib.h usbmain.c usbmain.h usbout.c usbout.h usbsetup.c usbsetup.h
  group Readme
    ../readme/: readme.txt

# Keil uVision project DolphinGames.uvproj, settings and files
target DolphinGames (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DolphinGames +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\Core\CM3;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries;..\Startup;..\User;..\User\inc;..\User\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
  group User Code
    ../User/src/: main.c CAN.c Communi.C Function.C stm32f10x_it.c Delay.C STM32_Init.c Retarget.c GameParam.c Target.c Queue.C Spi_FRAM.c Uart4.c Timer5.c Uart.c IOInput.c Uart1.c Game.C ColorSensor.c StateCtrl.c Small_Lcd.c STM32_Function.c UARTx.h Uart2.c Uart3.c Uart5.c
  group CMSIS
    ../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group Library
    ../Libraries/: STM3210E-EVAL.lib

# Keil uVision project .Cabinet.uvprojx, settings and files
target Cabinet (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Cabinet
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Main
    ./Source/: Main.c Retarget.c stm32f10x_it.c
  group W5500
    ./Source/W5500/Application/: Application.c loopback_client.c loopback_server.c
    ./Source/W5500/Ethernet/: socket.c wizchip_conf.c
    ./Source/W5500/Platform/: gpio_w5500.c
    ./Source/W5500/Ethernet/W5500/: w5500.c
    ./Source/W5500/Application/Buffer/PfmBuffer/: pfmBuffer.c
  group System
    ./Source/System/: DMA.c NVIC.c RCC.c SID.c
    ./Source/System/CAN/: can1.c
    ./Source/System/CRC/: crc.c
    ./Source/System/Delay/: delay.c SysTick.c
    ./Source/System/Malloc/: malloc.c
    ./Source/System/SPI/: spi1.c spi2.c spi3.c
    ./Source/System/Timer/: timer1.c timer2.c timer3.c timer4.c
    ./Source/System/Usart/: usart1.c usart3.c usart.c
    ./Source/System/flash/: flash.c SST25_Flash.c W25X_flash.c
    ./Source/System/RTC/: rtc.c
  group LCD12864
    ./Source/LCD12864/: LCD12864_gpio.c
    ./Source/LCD12864/LCD12864P/: LCD12864P.C LCD12864P_main.C
  group GPIO
    ./Source/GPIO/: in.c led.c out.c
  group PS2
    ./Source/PS2/: ps2.c
    ./Source/PS2/keyboard/: keyboard.c
    ./Source/PS2/mouse/: mouse.c
  group Nordic
    ./Source/Nordic/Application/: NRF2401_main.c SPI_NRF.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:CRC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StdPeriph Drivers:WWDG 3.5.0

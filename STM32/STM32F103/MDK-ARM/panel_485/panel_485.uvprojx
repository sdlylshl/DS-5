# Keil uVision project panel_485.uvprojx, settings and files
target panel_can (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103 +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Main
    ../../Source/: Retarget.c
    ./: main_panel485.c
  group System
    ../../Source/System/Usart/: usart1.c usart2.c
    ../../Source/System/CAN/: can1.c
    ../../Source/System/Delay/: SysTick.c
    ../../Source/System/Timer/: timer4.c
  group panel
    ../../Source/panel/: RS485.c panel_485.c
  group LCD1602
    ../../Source/LCD1602/: lcd_1602a.c
  group GPIO
    ../../Source/GPIO/: Beep.c led.c
  group Key
    ../../Source/Key/: key.c
  group Algorithm
    ../../Source/Algorithm/Buffer/: Buffer.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0

# Keil uVision project W5500.uvprojx, settings and files
target W5500 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103 +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Source\FatFs\R0.11\option;..\..\Source\FatFs\R0.11\drivers;..\..\Source\FatFs\R0.11
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Main
    ../../Source/: Retarget.c
    ./: main_W5500.c
  group System
    ../../Source/System/Usart/: usart1.c
    ../../Source/System/SPI/: spi2.c spi1.c
    ../../Source/System/Timer/: timer4.c
    ../../Source/System/CRC/: crc.c
    ../../Source/System/Delay/: delay.c
  group W5500
    ../../Source/W5500/Application/: Application.c loopback_client.c loopback_server.c pfmBuffer.c
    ../../Source/W5500/Ethernet/: socket.c wizchip_conf.c
    ../../Source/W5500/Ethernet/W5500/: w5500.c
    ../../Source/W5500/Platform/: w5500_gpio.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:CRC 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0

# Keil uVision project flash&FatFs.uvprojx, settings and files
target Flash&FatFs (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103 +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Source\FatFs\R0.11\option;..\..\Source\FatFs\R0.11\drivers;..\..\Source\FatFs\R0.11
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Main
    ../../Source/: Retarget.c
    ./: main_flash&FatFs.c
  group System
    ../../Source/System/Usart/: usart1.c
    ../../Source/System/SPI/: spi2.c spi1.c
  group FatFsR0.10b
    ../../Source/FatFs/R0.10b/: diskio.c ff.c ff_gen_drv.c
    ../../Source/FatFs/R0.10b/option/: syscall.c ccsbcs.c
    ../../Source/FatFs/R0.10b/drivers/: spi_diskio.c
  group SPIFlash
    ../../Source/SPIFlash/: SST25_Flash.c W25X_flash.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
